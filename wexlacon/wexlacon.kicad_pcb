# Repository kmzbrnoI/hWexla

File README.md:

hWexla – Switch motor
=====================

hWexla is a switch motor designed in [Model Railroader Club Brno I](https://kmz-brno.cz/)
to switch their turnouts. The project is opensource & openhardware, this repository
contains all data.

## Features

* Model 9g servo used as a drive force.
* Magnetic detection of movement. No mechanical parts detecting servo movement.
* Installation via unified D-SUB 25 connector.
* 2 inputs for position setting.
* 2 outputs for position indication (up to 200 mA).
* 2 IO pins for debug/panel.
* 2×3 relay for switching track current (up to 3 A).
* Diagnostic interface.
* IO protection.
* Slave mode.
* Input voltage: 10–20 V.
* Stabilizing of servo-voltage is solved in external board – hWexla contains
  only connector. Stepdowns like [RB0005](https://github.com/RoboticsBrno/RB0005-UniversalStepDown)
  are expected to be used.

## Parts

1. [PCB](pcb)
2. [Firmware](fw)
3. [WEXLACON PCB](wexlacon)
4. [Diagnostic PCB](diagpcb)

## [Requirements](requirements.md)

In czech only

## Piece check

Pass following checks to mark a piece of (newly manufactured) hWexla as
*quality check pass*.

1. Optical inspection.
2. Check programming interface is working.
3. Check diagnostic interface is working (browser visible, accepting commands).
4. Check all inputs are working (browser + functional test).
5. Check all outputs are working (browser + HW tester).
6. Check servo moves in full range.
7. Check magnet values, test signalization of end-position-reached.
8. Check relay output.
9. Monitor recorded minimum&maximum servo voltage.
10. Check for errors/warnings (browser).

## Authors

hWexla was designed in [Model Railroaders Club
Brno](https://www.kmz-brno.cz/) by [Jan Horáček](mailto:jan.horacek@kmz-brno.cz).

## KiCad design wexlacon/wexlacon.kicad_pcb

File wexlacon/README.md:

WEXLACON
========

WEXLACON is a PCB permanently mounted to the railway layout to which hWexla connects.

Schematic and the PCB was designed in KiCad 9.

## Authors

hWexla was designed in [Model Railroaders Club
Brno](https://www.kmz-brno.cz/) by [Jan Horáček](mailto:jan.horacek@kmz-brno.cz).

## License

Content of this directory is provided under [Creative Commons
Attribution-ShareAlike 4.0
License](https://creativecommons.org/licenses/by-sa/4.0/) as openhardware
project. You may download any data, contribute to the project, manufacture PCB
yourself or even sell it yourself.

Parts:
H1, H2, H3: M3; MountingHole_3.2mm_M3_Pad
H5: 1.0mm; TestPoint_THTPad_D2.0mm_Drill1.0mm
J1: MVE252-5-V
J3: KK-254; Molex_KK-254_AE-6410-04A_1x04_P2.54mm_Vertical
J5: CAN25; DSUB-25_Female_Vertical_P2.77x2.84mm
J6: pinheader; PinHeader_2x04_P2.54mm_Vertical
J9: MVE253-5-V; RELAYCON
J10: solder; RELAYCON
R1, R2, R3: 10k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder

Connections:
+5V: J3.4, J5.19, R1.1, R2.1, R3.1
+12V: J1.1, J5.16, J5.17
BTN+: J3.1, J5.6, J6.7
BTN-: J3.2, J5.7, J6.8
GND: J1.2, J3.3, J5.14, J5.15, J6.1
IN+: J5.2, J6.4, R2.2
IN-: J5.1, J6.3, R1.2
IN-SLAVE: J5.3, J6.2, R3.2
OUT+: J5.4, J6.5
OUT-: J5.5, J6.6
RELA0: J5.22, J5.23, J9.2
RELA+: J5.24, J5.25, J9.3
RELA-: J5.20, J5.21, J9.1
RELB0: J5.10, J5.11, J10.2
RELB+: J5.8, J5.9, J10.1
RELB-: J5.12, J5.13, J10.3

Notes on the sheet:
Mounting holes
Turnout wire hole

Board: 2 copper layers, 42.0 x 50.0 mm, 13 parts (3 on the bottom side), 16 nets.

## KiCad design pcb/hwexla.kicad_pcb

File pcb/README.md:

hWexla PCB
==========

See main repository readme for more information.

## License

Content of this directory is provided under [Creative Commons
Attribution-ShareAlike 4.0
License](https://creativecommons.org/licenses/by-sa/4.0/) as openhardware
project. You may download any data, contribute to the project, create PCB
yourself or even sell it yourself.

Parts:
C1, C2, C13, C15: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C49678
C3: 1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C28323
C4: 100p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C1790
D1: GR; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder; LCSC C2297
D2: YEL; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder; LCSC C2296
D3: RED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder; LCSC C84256
D4, D5: SMF05; SOT-363_SC-70-6; LCSC C15879
F1: 200mA/460mA; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder; LCSC C69680
H1: ServoMount1; MountingHole_2.2mm_M2_Pad
H2: ServoMount2; MountingHole_2.2mm_M2_Pad
H3, H4: JLCPCB; ToolingHole_1.152mm; JLCPCB_IGNORE true
J1: DB25_Male; DSUB-25_Male_EdgeMount_P2.77mm; JLCPCB_IGNORE true
J2: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical; JLCPCB_IGNORE true
J3: AVR-ISP-6; PinSocket_2x03_P2.54mm_Vertical; JLCPCB_IGNORE true
J4: Conn_01x06; PinSocket_1x06_P2.54mm_Vertical; JLCPCB_IGNORE true
JP1, JP2: SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
R1, R3, R6, R7, R15, R16: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17414
R2, R4, R5: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17513
R8: 47k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17713
SW1: SW_Push; SW_SPST_Omron_B3FS-100xP; JLCPCB_IGNORE true
TP1: TestPoint; TestPoint_Pad_D1.5mm
TP2: TestPoint; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded; JLCPCB_IGNORE true
U1: ATmega8A-AU; TQFP-32_7x7mm_P0.8mm; LCSC C16190
U2: RR112-1; SOT-23W; JLCPCB_IGNORE true

Connections:
+12V: J1.16, J1.17; also elsewhere on the board
/BTN: R6.2, SW1.2, U1.24 (PC1)
/BTN+: J1.6; also elsewhere on the board
/BTN-: J1.7; also elsewhere on the board
/IN+: J1.2; also elsewhere on the board
/IN-: J1.1; also elsewhere on the board
/L-BTN+IN: U1.28 (PC5); also elsewhere on the board
/L-BTN+OUT: U1.1 (PD3); also elsewhere on the board
/L-BTN-IN: U1.27 (PC4); also elsewhere on the board
/L-BTN-OUT: U1.7 (XTAL1/PB6); also elsewhere on the board
/L-IN+: U1.26 (PC3); also elsewhere on the board
/L-IN-: U1.25 (PC2); also elsewhere on the board
/L-OUT+: U1.14 (PB2); also elsewhere on the board
/L-OUT-: U1.32 (PD2); also elsewhere on the board
/L-SERVO-VCC: C15.1, R15.2, R16.1, U1.23 (PC0)
/L-SLAVE: U1.8 (XTAL2/PB7); also elsewhere on the board
/LED-GR: R3.1, U1.9 (PD5)
/LED-RED: R5.1, U1.11 (PD7)
/LED-YEL: R4.1, U1.10 (PD6)
/OUT+: J1.4; also elsewhere on the board
/OUT-: J1.5; also elsewhere on the board
/REL-CONTROL: U1.2 (PD4); also elsewhere on the board
/RELA0: J1.22, J1.23; also elsewhere on the board
/RELA+: J1.24, J1.25; also elsewhere on the board
/RELA-: J1.20, J1.21; also elsewhere on the board
/RELB0: J1.10, J1.11; also elsewhere on the board
/RELB+: J1.8, J1.9; also elsewhere on the board
/RELB-: J1.12, J1.13; also elsewhere on the board
/SERVO-POWER-EN: U1.12 (PB0); also elsewhere on the board
/SERVO-PWM: R1.1, R2.2, U1.13 (PB1)
/SERVO-VCC: J2.2, R1.2, R15.1; also elsewhere on the board
/SLAVE: J1.3; also elsewhere on the board
GND: C1.1, C2.1, C3.1, C4.2, C13.1, C15.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.2 (A), D5.2 (A), H1.1, H2.1, J1.14, J1.15, J2.1, J3.6 (GND), J4.6, R16.2, SW1.1, TP2.1, U1.3 (GND), U1.5 (GND), U1.21 (GND), U2.3 (GND); also elsewhere on the board
MAG-SENSE: C4.1, R8.1, U1.22 (ADC7)
MISO: D4.4 (K), J3.1 (MISO), U1.16 (PB4)
MOSI: D4.5 (K), J3.4 (MOSI), U1.15 (PB3)
unnamed: D1.2 (A), R3.2
unnamed: D2.2 (A), R4.2
unnamed: D3.2 (A), R5.2
unnamed: F1.2, J1.19
unnamed: J2.3, R2.1
unnamed: J3.2 (VCC), JP1.1 (A)
unnamed: J4.4, JP2.2 (B)
unnamed: TP1.1, U1.19 (ADC6)
unnamed: C2.2, U1.20 (AREF)
unnamed: R8.2, U2.2 (VOUT)
RESET: D4.1 (K), J3.5 (~RST), R7.2, U1.29 (~RESET/PC6)
RxD: D5.6 (K), J4.3, U1.30 (PD0)
SCK: D4.6 (K), J3.3 (SCK), U1.17 (PB5)
TxD: D5.4 (K), J4.2, U1.31 (PD1)
VCC: C1.2, C3.2, C13.2, F1.1, JP1.2 (B), JP2.1 (A), R6.1, R7.1, U1.4 (VCC), U1.6 (VCC), U1.18 (AVCC), U2.1 (VCC); also elsewhere on the board

Notes on the sheet:
Variants: ATmega8a, ATmega328p, ATmega328pb
SERVO

Parts:
C5, C10: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C49678
C6: 22u/25V; C_0805_2012Metric; LCSC C45783
C7: 47u; C_0805_2012Metric; LCSC C16780
D7, D9: 1N5819; D_SOD-123; LCSC C191023
D10: SS34; D_SMA_Handsoldering; LCSC C8678
D11: BZX84C18; SOT-23; LCSC C841166
F2: 0.5A/1A; Fuse_2920_7451Metric; LCSC C2760297
F3: 500mA; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder; LCSC C3161978
J5: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical; JLCPCB_IGNORE true
Q1: BT148; SOT-223; LCSC C256433
R9: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17414
R10: 2k2; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17520
R17: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17513
U3: KA78M05_TO252; TO-252-2; LCSC C58069

Connections:
+12V: F2.2; also elsewhere on the board
/SERVO-POWER-EN: R17.1; also elsewhere on the board
/SERVO-VCC: F3.1; also elsewhere on the board
/power/STEPIN: C10.1, D7.2 (A), D10.1 (K), D11.3 (K), F2.1, J5.2, Q1.2 (A)
/power/STEPOUT: F3.2, J5.4
GND: C5.2, C6.2, C7.2, C10.2, D10.2 (A), J5.3, Q1.1 (K), R9.2, R10.1, U3.2 (GND); also elsewhere on the board
unnamed: C6.1, D7.1 (K), D9.1 (K), U3.1 (VI)
unnamed: C5.1, D11.1 (A), Q1.3 (G), R10.2
unnamed: J5.1, R9.1, R17.2
VCC: C7.1, D9.2 (A), U3.3 (VO); also elsewhere on the board

Notes on the sheet:
Power for servo & relay
SG90 consumes 350 mA in peak according to https://protosupplies.com/product/servo-motor-micro-sg90/ Measured max current by JH: 150 mA
External stepdown
Non-reversible
Power for logic
5-18 V, min 1 A

Parts:
C8, C9, C11, C12: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C49678
D14, D15, D16, D17: BAT54C; SOT-23; LCSC C37704
D18: BZX84C5V1; SOT-23; LCSC C962733
D19: BZX84C30; SOT-23; LCSC C2926248
F4, F5, F6: 50mA/150mA; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder; LCSC C20797
F7, F8, F9, F10: 200mA/460mA; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder; LCSC C69680
Q3, Q4, Q5, Q6: 2N7002; SOT-23; LCSC C8545
Q7, Q8: BT148; SOT-223; LCSC C256433
R12: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17414
R13, R20, R21: 2k2; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17520
RN1, RN3: 10k; R_Array_Concave_4x0603; LCSC C396839
RN2: 2k2; R_Array_Concave_4x0603; LCSC C136829
RN4: 470R; R_Array_Concave_4x0603; LCSC C705088

Connections:
/BTN+: F7.2; also elsewhere on the board
/BTN-: F8.2; also elsewhere on the board
/IN+: F5.2; also elsewhere on the board
/IN-: F6.2; also elsewhere on the board
/L-BTN+IN: RN2.5 (R4.2); also elsewhere on the board
/L-BTN+OUT: RN4.8 (R1.2); also elsewhere on the board
/L-BTN-IN: RN2.6 (R3.2); also elsewhere on the board
/L-BTN-OUT: RN4.6 (R3.2); also elsewhere on the board
/L-IN+: RN2.7 (R2.2); also elsewhere on the board
/L-IN-: RN2.8 (R1.2); also elsewhere on the board
/L-OUT+: RN4.5 (R4.2); also elsewhere on the board
/L-OUT-: RN4.7 (R2.2); also elsewhere on the board
/L-SLAVE: R13.1; also elsewhere on the board
/OUT+: F9.2; also elsewhere on the board
/OUT-: F10.2; also elsewhere on the board
/SLAVE: F4.2; also elsewhere on the board
GND: C8.2, C9.2, C11.2, C12.1, Q3.2 (S), Q4.2 (S), Q5.2 (S), Q6.2 (S), Q7.1 (K), Q8.1 (K), R20.1, R21.1, RN3.1 (R1.1), RN3.2 (R2.1), RN3.3 (R3.1), RN3.4 (R4.1); also elsewhere on the board
unnamed: D14.1, F4.1, R12.2, R13.2
unnamed: C8.1, D18.1 (A), Q7.3 (G), R20.2
unnamed: C11.1, D14.3, D15.3, D16.3, D18.3 (K), Q7.2 (A)
unnamed: C9.1, D19.1 (A), Q8.3 (G), R21.2
unnamed: C12.2, D17.3, D19.3 (K), Q8.2 (A)
unnamed: D16.2, F7.1, Q3.3 (D), RN1.1 (R1.1), RN2.4 (R4.1)
unnamed: Q3.1 (G), RN3.8 (R1.2), RN4.1 (R1.1)
unnamed: D16.1, F8.1, Q4.3 (D), RN1.2 (R2.1), RN2.3 (R3.1)
unnamed: Q4.1 (G), RN3.6 (R3.2), RN4.3 (R3.1)
unnamed: D17.2, F9.1, Q5.3 (D)
unnamed: Q5.1 (G), RN3.5 (R4.2), RN4.4 (R4.1)
unnamed: D17.1, F10.1, Q6.3 (D)
unnamed: Q6.1 (G), RN3.7 (R2.2), RN4.2 (R2.1)
unnamed: D15.1, F5.1, RN1.3 (R3.1), RN2.2 (R2.1)
unnamed: D15.2, F6.1, RN1.4 (R4.1), RN2.1 (R1.1)
VCC: R12.1, RN1.5 (R4.2), RN1.6 (R3.2), RN1.7 (R2.2), RN1.8 (R1.2); also elsewhere on the board

Parts:
C14: 22u; C_0805_2012Metric; LCSC C45783
D13: 1N4148; D_0805_2012Metric_Pad1.15x1.40mm_HandSolder; LCSC C2128
F11, F12: 2A; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder; LCSC C17888
K1: RS-5; HFD2; JLCPCB_IGNORE true
Q2: 2N7002; SOT-23; LCSC C8545
R11: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17414
R14: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17513

Connections:
/REL-CONTROL: R14.2; also elsewhere on the board
/RELA0: F11.2; also elsewhere on the board
/RELA+: K1.8; also elsewhere on the board
/RELA-: K1.10; also elsewhere on the board
/RELB0: F12.2; also elsewhere on the board
/RELB+: K1.5; also elsewhere on the board
/RELB-: K1.3; also elsewhere on the board
GND: C14.2, Q2.2 (S), R11.2; also elsewhere on the board
unnamed: D13.2 (A), K1.12, Q2.3 (D)
unnamed: F11.1, K1.9
unnamed: F12.1, K1.4
unnamed: Q2.1 (G), R11.1, R14.1
VCC: C14.1, D13.1 (K), K1.1; also elsewhere on the board

Notes on the sheet:
Do not fit fuses

Board: 4 copper layers, 53.5 x 53.0 mm, 92 parts (15 on the bottom side), 75 nets.

## KiCad design diagpcb/hwexladiag.kicad_pcb

Parts:
C1, C2: 22u; C_0805_2012Metric
D1: RED; LED_0805_2012Metric
J1: PINHEADER; PinHeader_1x06_P2.54mm_Vertical_SMD_Pin1Left
JP1: SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
Q1, Q2: 2N7002; SOT-23
R1, R2, R3, R4, R7: 10k; R_0805_2012Metric
R5: 4k7; R_0805_2012Metric
R6: 10R; R_0805_2012Metric
SW1: SW_Push; SW_SPST_EVQPE1
U1: HC05
U2: HT7533-1; SOT-89-3

Connections:
+3V3: C2.1, Q1.1 (G), Q2.1 (G), R2.1, R4.1, SW1.1, U1.12 (3V3), U2.3 (VOUT)
+5V: J1.4, R1.1, R3.1, R6.1
/HCRX: Q1.2 (S), R2.2, U1.2 (UART_RX)
/HCTX: Q2.2 (S), R4.2, U1.1 (UART_TX)
/wexlaRxD: J1.3, Q2.3 (D), R3.2
/wexlaTxD: J1.2, Q1.3 (D), R1.2
AT: J1.1, JP1.2 (B)
GND: C1.2, C2.2, D1.1 (K), J1.6, R7.2, U1.13 (GND), U1.21 (GND), U1.22 (GND), U2.1 (GND)
unnamed: D1.2 (A), R5.2
unnamed: JP1.1 (A), R7.1, SW1.2, U1.34 (PIO11)
unnamed: R5.1, U1.31 (PIO8)
unnamed: C1.1, R6.2, U2.2 (VIN)

Notes on the sheet:
Set AT to 3V3 to enter AT mode
AT MODE

Board: 2 copper layers, 17.2 x 30.0 mm, 17 parts (13 on the bottom side), 12 nets.
